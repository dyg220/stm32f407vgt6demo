# Keil uVision project F407-Demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407-Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Cmsis;..\User\inc;..\Library\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Cmsis
    ../Cmsis/: startup_stm32f40xx.s stm32f4xx_it.c system_stm32f4xx.c stm32f4xx.h
  group Library
    ../Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../User/src/: main.c led.c delay.c beep.c fire.c key.c adc.c at24c02.c breathe.c exti.c frequency.c function.c iic.c iwdg.c keytime.c nvic.c rgb.c rng.c sg90.c tim6.c tim7.c ultrasonic.c usart1.c wwdg.c spi.c w25q64.c
    ../User/inc/: main.h
